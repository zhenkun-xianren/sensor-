# Keil uVision project Differential_Pressure_Air_Velocity_Sensor_board.uvprojx, settings and files
target Differential_Pressure_Air_Velocity_Sensor_board (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x800FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3") TZ
  output: Differential_Pressure_Air_Velocity_Sensor_board +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=2
  c define: STM32F103xB,DEV_MODBUS_ENABLE_SEND=1,DEV_MODBUS_ENABLE_RESPONSE=1
  c include: ../Inc;../../APP/inc;../../Device/inc;../Drivers/CMSIS/Device/ST/STM32F1xx/Include;../Drivers/CMSIS/Include;../../Middleware/FreeRTOS/include;../../Middleware/FreeRTOS/portable/RVDS/ARM_CM3;../../Middleware/CmBacktrace/cm_backtrace
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Application/MDK-ARM
    ./: startup_stm32f103xb.s
  group Drivers/CMSIS
    ../Src/: system_stm32f1xx.c
  group Application/Board
    ../Src/: bsp_backtrace.c bsp_backtrace_fault.s bsp_uart.c bsp_adc.c firmware_main.c bsp_actuator.c bsp_board.c bsp_byte_ring.c bsp_display.c bsp_freertos.c bsp_gpio.c bsp_ir.c bsp_rs485.c
  group Application/Port
    ../Src/: port_uart.c port_adc.c port_actuator.c port_display.c port_gpio.c port_ir_remote.c port_modbus.c
  group Application/APP
    ../../APP/src/: app_uart_echo.c app_measurement.c app_actuator.c app_display.c app_ir.c app_main.c app_modbus.c
  group Middleware/FreeRTOS
    ../../Middleware/FreeRTOS/: tasks.c list.c queue.c timers.c
    ../../Middleware/FreeRTOS/portable/RVDS/ARM_CM3/: port.c
    ../../Middleware/FreeRTOS/portable/MemMang/: heap_4.c
  group Middleware/CmBacktrace
    ../../Middleware/CmBacktrace/cm_backtrace/: cm_backtrace.c
software components: CMSIS:CORE 4.3.0
