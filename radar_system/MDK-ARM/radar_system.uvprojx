# Keil uVision project radar_system.uvprojx, settings and files
target radar_system (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x800F7FF)  CLOCK(8000000) CPUTYPE("Cortex-M3") TZ
  output: radar_system +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32F103xB,DISPLAY_CONFIG_DIGIT_COUNT=3,DEV_MODBUS_ENABLE_READ=1,DEV_MODBUS_ENABLE_SEND=0,DEV_MODBUS_ENABLE_WRITE=0
  c include: ../../Device/inc;../Core/Inc;../Drivers/STM32F1xx_HAL_Driver/Inc;../Drivers/STM32F1xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32F1xx/Include;../Drivers/CMSIS/Include;../../APP/inc;../../Middleware/FreeRTOS/include;../../Middleware/FreeRTOS/portable/RVDS/ARM_CM3
  memory RVCT4: ROM 0x8000000 size 0xf800
  memory RVCT9: RAM 0x20000000 size 0x5000
  scatter file: .\radar_layout.sct
  group Application/MDK-ARM
    ./: startup_stm32f103xb.s
  group Application/User/Core
    ../Core/Src/: stm32f1xx_it.c stm32f1xx_hal_msp.c
  group Drivers/STM32F1xx_HAL_Driver
    ../Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_tim.c stm32f1xx_hal_tim_ex.c stm32f1xx_hal.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_dma.c stm32f1xx_hal_cortex.c stm32f1xx_hal_pwr.c stm32f1xx_hal_flash.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal_exti.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f1xx.c
  group Copied_Drivers
    ../Core/Src/: bsp_gpio.c port_gpio.c bsp_actuator.c port_actuator.c bsp_rs485.c port_modbus.c bsp_byte_ring.c
  group Display
    ../Core/Src/: port_display.c bsp_display.c
  group Key
    ../Core/Src/: bsp_key.c port_key.c
  group Board_Startup
    ../Core/Src/: bsp_board.c firmware_main.c
  group APP
    ../../APP/src/: app_display.c app_key.c app_main.c app_freertos.c app_rs485.c
  group FreeRTOS
    ../../Middleware/FreeRTOS/: tasks.c queue.c list.c timers.c
    ../../Middleware/FreeRTOS/portable/RVDS/ARM_CM3/: port.c
    ../../Middleware/FreeRTOS/portable/MemMang/: heap_4.c
  group Flash_Settings
    ../../APP/src/: app_settings.c
    ../Core/Src/: port_flash.c bsp_flash.c
software components: CMSIS:CORE 4.3.0
