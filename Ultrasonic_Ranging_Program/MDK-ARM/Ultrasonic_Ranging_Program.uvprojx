# Keil uVision project Ultrasonic_Ranging_Program.uvprojx, settings and files
target Ultrasonic_Ranging_Program (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32G071RBTx STMicroelectronics
  pack: Keil.STM32G0xx_DFP.1.2.0
  cpu: IRAM(0x20000000-0x20008FFF) IROM(0x8000000-0x801FFFF) CLOCK(8000000) CPUTYPE("Cortex-M0+") TZ
  output: Ultrasonic_Ranging_Program +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=2
  c define: STM32G071xx,DEV_MODBUS_ENABLE_SEND=1,DEV_MODBUS_ENABLE_RESPONSE=0,CMB_USER_CFG=1
  c include: ../Core/Inc;../Drivers/CMSIS/Device/ST/STM32G0xx/Include;../Drivers/CMSIS/Include;../../APP/inc;../../Device/inc;../../Middleware/FreeRTOS/include;../../Middleware/FreeRTOS/portable/RVDS/ARM_CM0;../../Middleware/CmBacktrace/cm_backtrace
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x9000
  group Application/MDK-ARM
    ./: startup_stm32g071xx.s
  group Application/User
    ../Core/Src/: firmware_main.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32g0xx.c
  group APP
    ../../APP/src/: app_key_control.c app_main.c app_runtime.c app_example.c app_actuator.c app_modbus.c app_display.c app_ir_remote.c app_ultrasonic_tx.c app_ultrasonic_range.c
    ../../APP/inc/: app_actuator.h app_modbus.h app_ultrasonic_tx.h app_ultrasonic_range.h
  group Device
    ../../Device/inc/: dev_example.h dev_actuator.h dev_display.h dev_modbus.h dev_modbus_config.h dev_ir_remote.h dev_gpio.h dev_common.h dev_ultrasonic_tx.h dev_ultrasonic_range.h
  group Port
    ../Core/Src/: port_example.c port_actuator.c port_display.c port_modbus.c port_ir_remote.c port_gpio.c port_ultrasonic_tx.c port_ultrasonic_range.c
    ../Core/Inc/: port_actuator.h port_display.h port_modbus.h port_ir_remote.h port_gpio.h port_ultrasonic_tx.h port_ultrasonic_range.h
  group BSP
    ../Core/Src/: bsp_time.c bsp_interrupt.c bsp_board.c bsp_fault.c bsp_rtos.c bsp_example.c bsp_actuator.c bsp_startup.c bsp_display.c bsp_rs485.c bsp_ir.c bsp_gpio.c bsp_ultrasonic_tx.c bsp_backtrace.c bsp_backtrace_fault.s bsp_ultrasonic_range.c
    ../Core/Inc/: bsp_time.h FreeRTOSConfig.h bsp_actuator.h bsp_startup.h bsp_display.h bsp_rs485.h bsp_ir.h bsp_gpio.h bsp_gpio_board.h bsp_ultrasonic_tx.h bsp_backtrace.h cmb_user_cfg.h bsp_ultrasonic_range.h
  group CmBacktrace
    ../../Middleware/CmBacktrace/cm_backtrace/: cm_backtrace.c cm_backtrace.h cmb_def.h
  group FreeRTOS
    ../../Middleware/FreeRTOS/: tasks.c queue.c list.c timers.c
    ../../Middleware/FreeRTOS/portable/RVDS/ARM_CM0/: port.c
    ../../Middleware/FreeRTOS/portable/MemMang/: heap_4.c
software components: CMSIS:CORE 4.3.0
