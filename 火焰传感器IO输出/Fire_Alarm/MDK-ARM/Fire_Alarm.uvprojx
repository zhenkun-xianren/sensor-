# Keil uVision project Fire_Alarm.uvprojx, settings and files
target Fire_Alarm (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F051K8Tx STMicroelectronics
  pack: Keil.STM32F0xx_DFP.2.1.0
  cpu: IRAM(0x20000000-0x20001FFF) IROM(0x8000000-0x800FFFF) CLOCK(8000000) CPUTYPE("Cortex-M0") TZ
  output: Fire_Alarm +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32F051x8
  c include: ../Core/Inc;../Drivers/STM32F0xx_HAL_Driver/Inc;../Drivers/STM32F0xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32F0xx/Include;../Drivers/CMSIS/Include;../../Device/inc;../../APP/inc
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group Application/MDK-ARM
    ./: startup_stm32f051x8.s
  group Application/User
    ../Core/Src/: firmware_main.c
    ../Core/Inc/: main.h stm32f0xx_it.h stm32f0xx_hal_conf.h
  group Drivers/STM32F0xx_HAL_Driver
    ../Drivers/STM32F0xx_HAL_Driver/Src/: stm32f0xx_hal_tim.c stm32f0xx_hal_tim_ex.c stm32f0xx_hal_rcc.c stm32f0xx_hal_rcc_ex.c stm32f0xx_hal.c stm32f0xx_hal_i2c.c stm32f0xx_hal_i2c_ex.c stm32f0xx_hal_gpio.c stm32f0xx_hal_dma.c stm32f0xx_hal_cortex.c stm32f0xx_hal_pwr.c stm32f0xx_hal_pwr_ex.c stm32f0xx_hal_flash.c stm32f0xx_hal_flash_ex.c stm32f0xx_hal_exti.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f0xx.c
  group APP
    ../../APP/inc/: app_flame_config.h app_flame_detection.h app_flame_protocol.h app_main.h
    ../../APP/src/: app_flame_config.c app_flame_detection.c app_flame_protocol.c app_main.c
  group Device
    ../../Device/inc/: dev_common.h dev_modbus_slave.h dev_modbus_slave_config.h dev_gpio.h dev_actuator.h dev_actuator_config.h dev_flame.h
  group Port
    ../Core/Src/: port_modbus_slave.c port_gpio.c port_actuator.c port_flame.c
    ../Core/Inc/: port_modbus_slave.h port_gpio.h port_actuator.h port_flame.h
  group BSP
    ../Core/Src/: bsp_board.c bsp_rs485.c bsp_gpio.c bsp_actuator.c bsp_flame.c
    ../Core/Inc/: bsp_board.h bsp_rs485.h bsp_gpio.h bsp_gpio_board.h bsp_actuator.h bsp_flame.h
software components: CMSIS:CORE 4.3.0
