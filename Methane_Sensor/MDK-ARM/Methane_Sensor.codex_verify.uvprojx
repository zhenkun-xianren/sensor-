# Keil uVision project Methane_Sensor.codex_verify.uvprojx, settings and files
target Methane_Sensor (6240000::V6.24::.\ARMCLANG)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x800FFFF) CLOCK(64000000) CPUTYPE("Cortex-M3") TZ
  output: Methane_Sensor_codex_verify +hex
  c flags: Optim=7 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: USE_HAL_DRIVER,STM32F103xB
  c include: ../Core/Inc;../../APP/inc;../../Device/inc;../../Middleware/FreeRTOS/include;../../Middleware/FreeRTOS/portable/GCC/ARM_CM3;../Drivers/STM32F1xx_HAL_Driver/Inc;../Drivers/STM32F1xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32F1xx/Include;../Drivers/CMSIS/Include
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Application/MDK-ARM
    ./: startup_stm32f103xb.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c tim.c usart.c stm32f1xx_it.c stm32f1xx_hal_msp.c
  group Drivers/STM32F1xx_HAL_Driver
    ../Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_tim.c stm32f1xx_hal_tim_ex.c stm32f1xx_hal.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_dma.c stm32f1xx_hal_cortex.c stm32f1xx_hal_pwr.c stm32f1xx_hal_flash.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal_exti.c stm32f1xx_hal_uart.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f1xx.c
  group Application/APP
    ../../APP/src/: app_main.c app_display.c
  group Application/Port
    ../Core/Src/: port_display.c port_methane.c port_ir_remote.c port_gpio.c
  group Application/BSP
    ../Core/Src/: bsp_gpio.c bsp_display.c bsp_uart3.c bsp_byte_ring.c bsp_display_map.c bsp_ir.c bsp_actuator.c port_actuator.c
  group FreeRTOS/Kernel
    ../../Middleware/FreeRTOS/: tasks.c queue.c timers.c list.c
    ../../Middleware/FreeRTOS/portable/GCC/ARM_CM3/: port.c
    ../../Middleware/FreeRTOS/portable/MemMang/: heap_4.c
software components: CMSIS:CORE 5.0.2
