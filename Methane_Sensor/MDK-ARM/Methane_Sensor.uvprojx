# Keil uVision project Methane_Sensor.uvprojx, settings and files
target Methane_Sensor_V5 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x800FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3") TZ
  output: Methane_Sensor_V5 +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: STM32F103xB,FREERTOS_ARM_COMPILER=5
  c include: ../Core/Inc;../Drivers/CMSIS/Device/ST/STM32F1xx/Include;../Drivers/CMSIS/Include;../../APP/inc;../../Device/inc;../../Middleware/FreeRTOS/include;../../Middleware/FreeRTOS/portable/RVDS/ARM_CM3
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Application/MDK-ARM
    ./: startup_stm32f103xb.s
  group Application/User/Core
    ../Core/Src/: firmware_main.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f1xx.c
  group Application/APP
    ../../APP/src/: app_rs485.c app_display.c app_main.c app_ir_remote.c
  group Application/Port
    ../Core/Src/: port_modbus.c port_oled.c port_ir_remote.c
  group Application/BSP
    ../Core/Src/: bsp_rs485.c bsp_byte_ring.c bsp_board.c bsp_freertos.c bsp_oled.c bsp_time.c bsp_ir.c
  group FreeRTOS/Kernel
    ../../Middleware/FreeRTOS/: tasks.c queue.c list.c timers.c freertos_port_select.c
    ../../Middleware/FreeRTOS/portable/MemMang/: heap_4.c
software components: CMSIS:CORE 5.0.2
