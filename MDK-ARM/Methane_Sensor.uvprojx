# Keil uVision project Methane_Sensor.uvprojx, settings and files
target Methane_Sensor_V5 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x800FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3") TZ
  output: Methane_Sensor_V5 +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: STM32F103xB,FREERTOS_ARM_COMPILER=5
  c include: ../Inc;../Drivers/CMSIS/Device/ST/STM32F1xx/Include;../Drivers/CMSIS/Include;../APP/inc;../Device/inc;../Middleware/FreeRTOS/include;../Middleware/FreeRTOS/portable/RVDS/ARM_CM3
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Application/MDK-ARM
    ./: startup_stm32f103xb.s
  group Application/User/Core
    ../Src/: firmware_main.c
  group Drivers/CMSIS
    ../Src/: system_stm32f1xx.c
  group Application/APP
    ../APP/src/: app_system.c app_modbus.c app_display.c app_main.c app_ir_relay.c app_buzzer.c
  group Device/Modbus
    ../Device/src/: dev_modbus.c
  group Application/Port
    ../Src/: port_display.c port_modbus.c port_ir_remote.c port_actuator.c
  group Application/BSP
    ../Src/: bsp_byte_ring.c bsp_board.c bsp_freertos.c bsp_display.c bsp_gpio.c bsp_interrupt.c bsp_display_map.c bsp_ir.c bsp_actuator.c bsp_time.c bsp_rs485.c
  group FreeRTOS/Kernel
    ../Middleware/FreeRTOS/: tasks.c queue.c list.c timers.c freertos_port_select.c
    ../Middleware/FreeRTOS/portable/MemMang/: heap_4.c
software components: CMSIS:CORE 5.0.2
