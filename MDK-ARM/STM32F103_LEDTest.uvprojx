# Keil uVision project STM32F103_LEDTest.uvprojx, settings and files
target STM32F103_LEDTest_V5 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x800FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3") TZ
  output: STM32F103_LEDTest_V5 +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: STM32F103xB,FREERTOS_ARM_COMPILER=5
  c include: ../Inc;../Drivers/CMSIS/Device/ST/STM32F1xx/Include;../Drivers/CMSIS/Include;../APP/inc;../Device/inc;../Middleware/FreeRTOS/include;../Middleware/FreeRTOS/portable/RVDS/ARM_CM3
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Application/MDK-ARM
    ./: startup_stm32f103xb.s
  group Application/Handwritten
    ../Src/: firmware_main.c bsp_board.c bsp_gpio.c bsp_time.c bsp_interrupt.c
  group Drivers/CMSIS
    ../Src/: system_stm32f1xx.c
  group Application/FreeRTOS
    ../Src/: bsp_freertos.c
    ../APP/src/: app_main.c app_system.c
  group Middleware/FreeRTOS/Core
    ../Middleware/FreeRTOS/: tasks.c list.c queue.c timers.c
  group Middleware/FreeRTOS/Port
    ../Middleware/FreeRTOS/: freertos_port_select.c
  group Middleware/FreeRTOS/Memory
    ../Middleware/FreeRTOS/portable/MemMang/: heap_4.c
  group Application/Display
    ../APP/src/: app_display.c
    ../Src/: port_display.c bsp_display.c bsp_display_map.c
  group Application/Buzzer
    ../APP/src/: app_buzzer.c
    ../Src/: port_actuator.c bsp_actuator.c
  group Application/Infrared
    ../APP/src/: app_ir_relay.c
    ../Src/: port_ir_remote.c bsp_ir.c
  group Board Support/Byte Ring
    ../Src/: bsp_byte_ring.c
  group Device/Modbus
    ../Device/src/: dev_modbus.c
  group Port/Modbus
    ../Src/: port_modbus.c
  group Board Support/RS485
    ../Src/: bsp_rs485.c
target STM32F103_LEDTest_V6 (6090000::V6.9::.\ARMCLANG)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: as above
  output: STM32F103_LEDTest_V6 +hex
  c flags: Optim=7 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: STM32F103xB,FREERTOS_ARM_COMPILER=6
  c include: ../Inc;../Drivers/CMSIS/Device/ST/STM32F1xx/Include;../Drivers/CMSIS/Include;../APP/inc;../Device/inc;../Middleware/FreeRTOS/include;../Middleware/FreeRTOS/portable/GCC/ARM_CM3
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
software components: CMSIS:CORE 5.0.2
